Commit message: Update irb1600id.urdf

File: urdf/irb1600id.urdf (robot description, URDF)
Before this commit: robot abb_irb1600id, 8 links, 7 joints
Joints:
- joint joint_1: origin xyz=0 0 0 rpy=0 0 0 -> xyz=0 0 0.5 rpy=0 0 0
